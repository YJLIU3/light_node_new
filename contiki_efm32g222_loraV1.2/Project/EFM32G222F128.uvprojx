# Keil uVision project EFM32G222F128.uvprojx, settings and files
target LORA (ARM-ADS)
  device: EFM32G222F128 Silicon Labs
  pack: Keil.EFM32Gxxx_DFP.1.2.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: EFM32G222F128
  c flags: Optim=1 wLevel=2
  c define: USE_BAND_433 EFM32G222F128
  c misc: --c99
  c include: ..\Project;..\CMSIS\startup;..\emlib\src;..\emlib\inc;..\Device;..\CMSIS;..\USER\Main;..\USER\Board\RCC;..\USER\Board\LED;..\contiki-2.7\core;..\contiki-2.7\cpu;..\contiki-2.7\core\lib;..\contiki-2.7\core\ctk;..\contiki-2.7\core\sys;..\USER\contiki;..\contiki-2.7\cpu\arm\stm32f103;..\USER\Board\Rtc;..\USER\Board\TIME;..\USER\app_task;..\USER\Board\LEUSART;..\USER\Board\SPI;..\Peripheral\SX1278\hal;..\Peripheral\SX1278\radio;..\LoraWan\crypto;..\LoraWan\mac;..\USER\Board\WTD;..\USER\Board\USER_DATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ../CMSIS/startup/: system_efm32g.c startup_efm32g.s
  group CMSIS
    ../CMSIS/: core_cm3.h
  group mian
    ../USER/Main/: main.c
  group board
    ../USER/Main/: sysdelay.c
    ../USER/Board/LED/: LED.c
    ../USER/Board/RCC/: rcc.c
    ../USER/Board/Rtc/: rtc.c
    ../USER/Board/TIME/: time.c
    ../USER/Board/LEUSART/: leusart.c
    ../USER/Board/SPI/: spi0.c
    ../USER/Board/WTD/: WDT.c
    ../USER/Board/USER_DATA/: user_data.c
    ./: gyiic.c GY30.c DHT11.c
  group emlib
    ../emlib/src/: em_system.c em_cmu.c em_gpio.c em_emu.c em_rtc.c em_timer.c em_leuart.c em_usart.c em_wdog.c em_rmu.c em_msc.c
  group contiki_cpu
    ../contiki-2.7/cpu/arm/stm32f103/: clock.c
  group contiki_sys
    ../contiki-2.7/core/sys/: autostart.c etimer.c process.c timer.c rtimer.c ctimer.c stimer.c
    ../contiki-2.7/cpu/arm/stm32f103/: rtimer-arch.c
    ../contiki-2.7/core/lib/: list.c
  group contiki_app
    ../USER/Board/app_task/: app_task.c
  group mac
    ../LoraWan/mac/: LoRaMac.c LoRaMac-api-v3.c LoRaMacCrypto.c
  group radio
    ../Peripheral/SX1278/hal/: sx1276_hal.c
    ../Peripheral/SX1278/radio/: sx1276.c
  group crypto
    ../LoraWan/crypto/: aes.c cmac.c utilities.c
